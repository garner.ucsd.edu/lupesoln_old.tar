b
elupe1.075          
xgair1.075                                                                      
tlupe1.075          
y
